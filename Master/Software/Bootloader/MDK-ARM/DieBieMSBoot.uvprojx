# Keil uVision project DieBieMSBoot.uvprojx, settings and files
target DieBieMSBoot (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F303CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DieBieMSBoot +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c misc: --C99
  c include: ../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;..\Main;..\Device;..\Drivers\HWDrivers\Inc;..\Drivers\HWDrivers\Src;..\Drivers\SWDrivers\Inc;..\Drivers\SWDrivers\Src;..\Libraries\Inc;..\Libraries\Src;..\Modules\Inc;..\Modules\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8032000 size 0xd800
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Driver/HALDriver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_nand.c stm32f3xx_hal_nor.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pccard.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_fmc.c
  group Driver/HWDriver
    ../Drivers/HWDrivers/Src/: driverHWI2C1.c driverHWPowerState.c driverHWStatus.c
  group Driver/SWDriver
    ../Drivers/SWDrivers/Src/: driverSWSSD1306.c
  group Modules
    ../Modules/Src/: modDelay.c modDisplay.c modEffect.c modFlash.c
  group Libraries
    ../Libraries/Src/: libBuffer.c libCRC.c libGLCDFont.c libGraphics.c libPacket.c libRingbuffer.c
  group Device
    ../Device/: startup_stm32f303xc.s stm32f3xx_hal_msp.c stm32f3xx_it.c
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Main
    ../Main/: main.c
software components: CMSIS:CORE 5.0.0
